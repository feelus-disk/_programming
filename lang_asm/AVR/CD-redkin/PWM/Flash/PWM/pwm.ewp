# IAR project pwm.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  ICCARM.CCIncludePath2: ..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: FLASH_DEBUG
  AARM.AUserIncludes: ..\..\include\
  XLINK.XclFile: at91SAM7S64_Remap.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: board.c Board.h Cstartup.s79 Cstartup_SAM7.c interrupt_timer.c knop.c lcd.c lib_pwm.c lib_pwm.h main.c
