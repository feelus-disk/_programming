# IAR project Lcd_knop_X128.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7X128 Atmel AT91SAM7X128
  ICCARM.CCIncludePath2: ..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: FLASH_DEBUG
  AARM.AUserIncludes: ..\..\include\
  XLINK.XclFile: at91SAM7X128_FLASH.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: board.c Board.h Cstartup.s79 Cstartup_SAM7.c interrupt_timer.c knop.c lcd.c main.c project.h
